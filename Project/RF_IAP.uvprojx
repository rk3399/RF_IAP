# Keil uVision project RF_IAP.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wifi +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\Common;..\Main;..\Startup_config;..\STM32F4_FWLIB\inc;..\UCOSIII\APP;..\UCOSIII\BSP;..\UCOSIII\uC-CPU;..\UCOSIII\uC-PORT;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-LIB;..\USER;..\FatFs\inc;..\FatFs\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group USER
    ../USER/: AT_ESP8266.c IAP.c malloc.c SqQueue.c crc16.c
  group Common
    ../Common/: common.c
  group Startup_config
    ../Startup_config/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group STM32F4_FWLIB
    ../STM32F4_FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_exti.c stm32f4xx_spi.c
  group APP
    ../UCOSIII/APP/: app.c app_cfg.h os_cfg.h cpu_cfg.h os_cfg_app.h lib_cfg.h includes.h os_app_hooks.c os_app_hooks.h os_error_hendler.c
  group BSP
    ../UCOSIII/BSP/: bsp.c bsp.h beep.c key.c led.c usart4_wifi.c usart.c hal_spi.c w25qxx.c
  group UCOS/Kernel
    ../UCOSIII/uCOS-III/Source/: os_type.h os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOS/Port
    ../UCOSIII/uC-PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOS/Lib
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOS/Cpu
    ../UCOSIII/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group FatFs
    ../FatFs/inc/: ffconf.h
    ../FatFs/: fatfs.c
    ../FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../FatFs/src/option/: syscall.c
software components: CMSIS:CORE 5.2.0
